# IAR project sd_init.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-1s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm8.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-0t-n.h
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\lnk0t.xcl
  group (top)
    ./: ATSHA_Authentication_PL1.c ATSHA_Authentication_PL1.h ATSHA_Commands_Module.c ATSHA_Commands_Module.h ATSHA_EmulatingSoftware_Module.c ATSHA_EmulatingSoftware_Module.h ATSHA_PL2.c ATSHA_PL2.h I2C_ACK_NACK_Generation.c I2C_ACK_NACK_Generation.h I2C_Protocol.c I2C_Protocol.h
